# IAR project Backup (2) of invincible.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK60FX512xxx15 Freescale MK60FX512xxx15
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: IAR; DEBUG; ARM_MATH_CM4; MK60F15
  ICCARM.CCIncludePath2: ..\..\App; ..\..\App\Inc; ..\..\Board\Inc; ..\..\Chip\inc; ..\..\Chip\inc\IAR; ..\..\Chip\inc\kinetis; ..\..\Lib\CMSIS\Inc; ..\..\Hardware
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: invincible.hex
  ILINK.IlinkOutputFile: invincible.out
  ILINK.IlinkIcfFile: config files\512KB_Pflash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group App
    ../../App/: All_config.c Helper.c main.c MK60_it.c OLED.c
  group App/inc
    ../../App/Inc/: All_config.h CodeTable.h Helper.h include.h MK60_it.h OLED.h
  group Board/inc
    ../../Board/inc/: FIRE_ASCII.h FIRE_key.h FIRE_key_event.h FIRE_LED.H FIRE_MK60_conf.h FIRE_PORT_cfg.h FIRE_RTC_count.h FIRE_UI_VAR.h
  group Board/src
    ../../Board/src/: FIRE_ASCII.c FIRE_key.c FIRE_key_event.c FIRE_LED.C FIRE_MK60_conf.c FIRE_RTC_count.C
  group Chip/inc/IAR
    ../../Chip/inc/IAR/: iar.h system_MK60DZ10.h
  group Chip/inc/kinetis
    ../../Chip/inc/kinetis/: MK10DZ10.h MK20DZ10.h MK30DZ10.h MK40DZ10.h MK50DZ10.h MK51DZ10.h MK52DZ10.h MK53DZ10.h MK60DZ10.h MK60F12.h MK60F15.h MK61F12.h MK61F15.h MK70F12.h MK70F15.h
  group Chip/src
    ../../Chip/src/: misc.c MK60_adc.c MK60_dma.c MK60_DWT.c MK60_flash.c MK60_flexbus.c MK60_ftm.c MK60_gpio.c MK60_i2c.c MK60_lptmr.c MK60_mcg.c MK60_PIT.c MK60_port.c MK60_rtc.c MK60_spi.c MK60_SysTick.c MK60_uart.c MK60_wdog.c vectors.c
  group Chip/src/IAR
    ../../Chip/src/IAR/: startup_MK60DZ10.s system_MK60DZ10.c
  group Hardware
    ../../Hardware/: mpu6050.c mpu6050.h
  group Lib/CMSIS/inc
    ../../Lib/CMSIS/Inc/: arm_common_tables.h arm_math.h core_cm0.h core_cm3.h core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h
  group Prj/config files
    config files/: 128KB_Pflash.icf 128KB_Pflash_128KB_Dflash.icf 128KB_Ram.icf 256KB_Pflash.icf 256KB_Pflash_256KB_Dflash.icf 32KB_Ram.icf 512KB_Pflash.icf 64KB_Pflash_64KB_Dflash.icf 64KB_Ram.icf fire_RAM_K60N512.icf fire_ROM_K60N512.icf
